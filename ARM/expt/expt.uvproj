# Keil uVision project expt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S) EBIG
  output: expt
  c flags: Optim=1
  group Source Group 1
    ./: Experiment1.s Experiment2.s Experiment3.s
