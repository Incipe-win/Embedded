# Keil uVision project 送p0.0引脚状态到p1.0，p2.0，p3.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 送p0.0引脚状态到p1.0，p2.0，p3.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 送p0.0引脚状态到p1.0，p2.0，p3.0.c
