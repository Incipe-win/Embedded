# Keil uVision project 用p1口显示左右移位运算结果.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 用p1口显示左右移位运算结果 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 用p1口显示左右移位运算结果.c
